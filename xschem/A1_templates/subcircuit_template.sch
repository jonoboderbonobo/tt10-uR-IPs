v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {ipin.sym} -110 -340 0 0 {name=p1 lab=Vdd}
C {ipin.sym} -110 -310 0 0 {name=p2 lab=Vss}
C {opin.sym} -110 -280 0 0 {name=p4 lab=Out}
C {lab_wire.sym} 10 -310 0 1 {name=p8 sig_type=std_logic lab=Vss}
C {lab_wire.sym} 10 -340 0 1 {name=p11 sig_type=std_logic lab=Vdd}
C {ipin.sym} -100 -250 0 0 {name=p3 lab=In}
C {lab_wire.sym} 10 -280 0 1 {name=p5 sig_type=std_logic lab=Out}
C {lab_wire.sym} 10 -240 0 1 {name=p6 sig_type=std_logic lab=In}
