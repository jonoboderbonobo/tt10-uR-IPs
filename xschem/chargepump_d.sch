v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {title.sym} 80 -30 0 0 {name=l1 author="Jonas Boerschmann"}
